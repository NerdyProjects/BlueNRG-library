<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_SerialPortMasterSlave_NWK.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>BLE_SerialPortMasterSlave_NWK</project>
                <configuration>BLE_SerialPortMasterSlave_NWK_SPI</configuration>
            </member>
            <member>
                <project>BLE_SerialPortMasterSlave_NWK</project>
                <configuration>BLE_SerialPortMasterSlave_NWK_UART</configuration>
            </member>
            <member>
                <project>BLE_SerialPortMasterSlave_NWK</project>
                <configuration>BLE_SerialPortMasterSlave_NWK_UART_HWFlowCtrl</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
