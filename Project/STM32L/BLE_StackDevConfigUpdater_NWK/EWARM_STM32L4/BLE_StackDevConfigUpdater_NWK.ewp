# IAR project BLE_StackDevConfigUpdater_NWK.ewp, settings and files
configuration DevConfig_Updater_UART (ARM)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; ENABLE_USART; UART_INTERFACE; BTLE_NWK_COPROC; APPLY_BLUENRG_DEV_CONFIG_UPDATER; BLUENRG2_DEVICE
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\Library\STM32L\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32Lxx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32Lxx_BlueNRG1\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\STM32L1xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_DevConfigUpdater_NWK_UART.hex
  ILINK.IlinkOutputFile: BLE_DevConfigUpdater_NWK_UART.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Stack_Updater_UART (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; ENABLE_USART; UART_INTERFACE; APPLY_BLUENRG_STACK_UPDATER; BTLE_NWK_COPROC; BLUENRG2_DEVICE
  OBJCOPY.OOCOutputFile: BLE_StackUpdater_NWK_UART.hex
  ILINK.IlinkOutputFile: BLE_StackUpdater_NWK_UART.out
configuration Stack_Updater_Ymodem_UART (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BLE_StackUpdater_NWK_Ymodem_UART.hex
  ILINK.IlinkOutputFile: BLE_StackUpdater_NWK_Ymodem_UART.out
configuration DevConfig_Updater_SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; ENABLE_USART; SPI_INTERFACE; BTLE_NWK_COPROC; APPLY_BLUENRG_DEV_CONFIG_UPDATER; BLUENRG2_DEVICE
  OBJCOPY.OOCOutputFile: BLE_DevConfigUpdater_NWK_SPI.hex
  ILINK.IlinkOutputFile: BLE_DevConfigUpdater_NWK_SPI.out
configuration Stack_Updater_SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; ENABLE_USART; SPI_INTERFACE; APPLY_BLUENRG_STACK_UPDATER; BTLE_NWK_COPROC; BLUENRG2_DEVICE
  OBJCOPY.OOCOutputFile: BLE_StackUpdater_NWK_SPI.hex
  ILINK.IlinkOutputFile: BLE_StackUpdater_NWK_SPI.out
configuration Stack_Updater_Ymodem_SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BLE_StackUpdater_NWK_Ymodem_SPI.hex
  ILINK.IlinkOutputFile: BLE_StackUpdater_NWK_Ymodem_SPI.out
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../src/: BLE_StackDevConfigUpdater_main.c BLE_StackUpdaterYmodem_main.c hci_parser.c stm32xx_it.c update_fw_image.c ymodem.c
  group Drivers/BSP/STM32L4xx_BlueNRG
    ../../../../Library/STM32L/Drivers/BSP/STM32Lxx_BlueNRG1/src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../Library/STM32L/Drivers/BSP/STM32Lxx_Nucleo/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Drivers/CMSIS
    ../../../../Library/STM32L/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Library/STM32L/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_hci_le.c bluenrg1_utils.c hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c osal.c
