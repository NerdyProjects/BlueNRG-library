# IAR project DTM_Updater.ewp, settings and files
configuration Release_SPI (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; SPI_INTERFACE; NO_SMART_POWER_MANAGEMENT
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_Updater.bin
  postbuild: "convert_bin2c.exe" -i "Release_SPI\Exe\DTM_Updater.bin" -o "DTM_Updater_SPI.c"
  ILINK.IlinkOutputFile: DTM_Updater.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x2000
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_UART_16MHz (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; UART_INTERFACE; SYSCLOCK_16MHZ; NO_SMART_POWER_MANAGEMENT
  postbuild: "convert_bin2c.exe" -i "Release_UART_16MHz\Exe\DTM_Updater.bin" -o "DTM_Updater_UART_16MHz.c"
configuration Release_UART_32MHz (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; UART_INTERFACE; SYSCLOCK_32MHZ; NO_SMART_POWER_MANAGEMENT
  postbuild: "convert_bin2c.exe" -i "Release_UART_32MHz\Exe\DTM_Updater.bin" -o "DTM_Updater_UART_32MHz.c"
  group User
    ../../src/: DTM_Updater.c DTM_Updater_boot.c DTM_Updater_main.c
