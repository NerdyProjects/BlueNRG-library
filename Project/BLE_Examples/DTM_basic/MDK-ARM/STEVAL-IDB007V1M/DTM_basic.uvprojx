# Keil uVision project DTM_basic.uvprojx, settings and files
target SPI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DTM_basic_SPI +hex
  AfterMake: fromelf.exe --bin SPI\Objects\DTM_basic_SPI.axf --output SPI\Objects\DTM_basic_SPI.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SPI_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: ..\..\..\DTM\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\hal\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
  group DTM_Updater
    ../../../DTM/DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Hal
    ../../../../../Library/hal/src/: context_switch.s fifo.c miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../../DTM/src/: BlueNRG1_it.c cmd.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c transport_layer.c
target SPI_NOUPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: DTM_basic_SPI_NOUPDATER +hex
  AfterMake: fromelf.exe --bin SPI_NOUPDATER\Objects\DTM_basic_SPI_NOUPDATER.axf --output SPI_NOUPDATER\Objects\DTM_basic_SPI_NOUPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: DTM_basic_UART +hex
  AfterMake: fromelf.exe --bin UART\Objects\DTM_basic_UART.axf --output UART\Objects\DTM_basic_UART.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: UART_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART_SLEEP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: DTM_basic_UART_SLEEP +hex
  AfterMake: fromelf.exe --bin UART_SLEEP\Objects\DTM_basic_UART_SLEEP.axf --output UART_SLEEP\Objects\DTM_basic_UART_SLEEP.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: UART_INTERFACE WATCHDOG WATCHDOG_TIME=1 UART_SLEEP BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART_NOUPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: DTM_basic_UART_NOUPDATER +hex
  AfterMake: fromelf.exe --bin UART_NOUPDATER\Objects\DTM_basic_UART_NOUPDATER.axf --output UART_NOUPDATER\Objects\DTM_basic_UART_NOUPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
