<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DTM.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>DTM</project>
                <configuration>SPI</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>SPI_NOUPDATER</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART_NOUPDATER</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART_SLEEP</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART_Throughput</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
