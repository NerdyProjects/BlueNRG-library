<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DTM_M2SA_M2SP.ewp</path>
  </project>
</workspace>



