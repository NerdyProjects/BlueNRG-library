# IAR project BLE_Beacon_FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SAVE_CONTEXT_ON_CSTACK=0; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\FreeRTOS\Source\include; ..\..\..\..\..\Library\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Library\FreeRTOS\BlueNRG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; CONTEXT_SAVE_V2
  AARM.AUserIncludes: ..\..\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include
  OBJCOPY.OOCOutputFile: BLE_Beacon_FreeRTOS.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_FreeRTOS.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_FreeRTOS.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FreeRTOS
    ../../../../../Library/FreeRTOS/BlueNRG/: freertos_lp.c
    ../../../../../Library/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../../../../Library/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../Library/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group OTA
    ../../../../../Library/BLE_Application/OTA/src/: OTA_btl.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Beacon_FreeRTOS_main.c BlueNRG1_it.c
