# IAR project BLE_Throughput.ewp, settings and files
configuration Client_unidirectional (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; CLIENT=1; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; THROUGHPUT_TEST_SERVER; UART_BAUDRATE=921600; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Throughput_Client_unidirectional.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Throughput_Client_unidirectional.bin"
  ILINK.IlinkOutputFile: BLE_Throughput_Client_unidirectional.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Server_unidirectional (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1; THROUGHPUT_TEST_SERVER; UART_BAUDRATE=921600; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: BLE_Throughput_Server_unidirectional.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Throughput_Server_unidirectional.bin"
  ILINK.IlinkOutputFile: BLE_Throughput_Server_unidirectional.out
configuration Client_bidirectional (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; CLIENT=1; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; THROUGHPUT_TEST_SERVER; THROUGHPUT_TEST_CLIENT; UART_BAUDRATE=921600; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: BLE_Throughput_Client_bidirectional.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Throughput_Client_bidirectional.bin"
  ILINK.IlinkOutputFile: BLE_Throughput_Client_bidirectional.out
configuration Server_bidirectional (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1; THROUGHPUT_TEST_SERVER; THROUGHPUT_TEST_CLIENT; UART_BAUDRATE=921600; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: BLE_Throughput_Server_bidirectional.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Throughput_Server_bidirectional.bin"
  ILINK.IlinkOutputFile: BLE_Throughput_Server_bidirectional.out
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: BLE_Throughput_main.c BlueNRG1_it.c gatt_db.c throughput.c
