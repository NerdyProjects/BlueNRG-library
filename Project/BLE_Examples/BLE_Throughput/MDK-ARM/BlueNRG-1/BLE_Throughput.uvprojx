# Keil uVision project BLE_Throughput.uvprojx, settings and files
target Client_unidirectional (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Throughput_Client_unidirectional +hex
  AfterMake: fromelf.exe --bin Client_unidirectional\Objects\BLE_Throughput_Client_unidirectional.axf --output Client_unidirectional\Objects\BLE_Throughput_Client_unidirectional.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION THROUGHPUT_TEST_SERVER UART_BAUDRATE=921600 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Throughput_main.c BlueNRG1_it.c gatt_db.c throughput.c
target Server_unidirectional (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Throughput_Server_unidirectional +hex
  AfterMake: fromelf.exe --bin Server_unidirectional\Objects\BLE_Throughput_Server_unidirectional.axf --output Server_unidirectional\Objects\BLE_Throughput_Server_unidirectional.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 THROUGHPUT_TEST_SERVER UART_BAUDRATE=921600 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Client_bidirectional (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Throughput_Client_bidirectional +hex
  AfterMake: fromelf.exe --bin Client_bidirectional\Objects\BLE_Throughput_Client_bidirectional.axf --output Client_bidirectional\Objects\BLE_Throughput_Client_bidirectional.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION THROUGHPUT_TEST_SERVER THROUGHPUT_TEST_CLIENT UART_BAUDRATE=921600 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Server_bidirectional (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Throughput_Server_bidirectional +hex
  AfterMake: fromelf.exe --bin Server_bidirectional\Objects\BLE_Throughput_Server_bidirectional.axf --output Server_bidirectional\Objects\BLE_Throughput_Server_bidirectional.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 THROUGHPUT_TEST_SERVER THROUGHPUT_TEST_CLIENT UART_BAUDRATE=921600 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
