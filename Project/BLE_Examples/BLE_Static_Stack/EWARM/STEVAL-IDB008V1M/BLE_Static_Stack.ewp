# IAR project BLE_Static_Stack.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: APP_OFFSET=0x1B800; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Static_Stack.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Library\Bluetooth_LE\library\static_stack\libbluenrg2_static_stack.a"
  ILINK.IlinkOutputFile: BLE_Static_Stack.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x1B800
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OTA_BTL_ResetManager (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; RESET_MANAGER_SIZE=0x1B800; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  OBJCOPY.OOCOutputFile: BLE_Static_Stack_OTA_BTL_ResetManager.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Library\Bluetooth_LE\library\static_stack\libbluenrg2_static_stack_with_resetmanager.a"
  ILINK.IlinkOutputFile: BLE_Static_Stack_OTA_BTL_ResetManager.out
  group BLE_Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_user_cfg.c
  group hal
    ../../../../../Library/hal/src/: context_switch.s miscutil.c osal.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_flash.c BlueNRG1_pka.c BlueNRG1_sysCtrl.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: bluenrg1_cmd_if.c bluenrg1_ev_if.c bluenrg1_it_stub.c OTA_ResetManager_main.c Reset_Manager.c
