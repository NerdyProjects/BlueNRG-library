# Keil uVision project BLE_Static_Stack.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Static_Stack +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_Static_Stack.axf --output Release\Objects\BLE_Static_Stack.bin
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks !L ..\..\..\..\..\Library\Bluetooth_LE\library\static_stack\libbluenrg1_static_stack.a
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: APP_OFFSET=0x1B000 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x1B000 "
  group BLE_Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_user_cfg.c
  group hal
    ../../../../../Library/hal/src/: context_switch.s miscutil.c osal.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_flash.c BlueNRG1_pka.c BlueNRG1_sysCtrl.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: bluenrg1_cmd_if.c bluenrg1_ev_if.c bluenrg1_it_stub.c OTA_ResetManager_main.c Reset_Manager.c
target OTA_BTL_ResetManager (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Static_Stack_OTA_BTL_ResetManager +hex
  AfterMake: fromelf.exe --bin OTA_BTL_ResetManager\Objects\BLE_Static_Stack_OTA_BTL_ResetManager.axf --output OTA_BTL_ResetManager\Objects\BLE_Static_Stack_OTA_BTL_ResetManager.bin
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks !L ..\..\..\..\..\Library\Bluetooth_LE\library\static_stack\libbluenrg1_static_stack_with_resetmanager.a
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION RESET_MANAGER_SIZE=0x1B000 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x1B000 "
