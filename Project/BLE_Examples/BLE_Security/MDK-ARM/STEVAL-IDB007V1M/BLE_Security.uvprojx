# Keil uVision project BLE_Security.uvprojx, settings and files
target Slave_PassKey_Random (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Security_Slave_PassKey_Random +hex
  AfterMake: fromelf.exe --bin Slave_PassKey_Random\Objects\BLE_Security_Slave_PassKey_Random.axf --output Slave_PassKey_Random\Objects\BLE_Security_Slave_PassKey_Random.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION SECURITY_MODE=PASSKEY_RANDOM_PIN BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: ..\..\inc\peripheral;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\BLE_Application\Profile_Central\includes
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Master_Library
    ../../../../../Library/BLE_Application/Profile_Central/library/: libmaster_library_bluenrg1.a
    ../../../../../Library/BLE_Application/Profile_Central/profiles/ble_profile/: master_events_CB.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User_Central
    ../../src/central/: BlueNRG1_it.c C_main.c gatt_db.c
  group User_Peripheral
    ../../src/peripheral/: BLE_Security_Peripheral.c BlueNRG1_it.c gatt_db.c P_main.c
target Master_PassKey_Random (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Master_PassKey_Random +hex
  AfterMake: fromelf.exe --bin Master_PassKey_Random\Objects\BLE_Security_Master_PassKey_Random.axf --output Master_PassKey_Random\Objects\BLE_Security_Master_PassKey_Random.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: ..\..\inc\central;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\BLE_Application\Profile_Central\includes
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Slave_PassKey_Fixed (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Slave_PassKey_Fixed +hex
  AfterMake: fromelf.exe --bin Slave_PassKey_Fixed\Objects\BLE_Security_Slave_PassKey_Fixed.axf --output Slave_PassKey_Fixed\Objects\BLE_Security_Slave_PassKey_Fixed.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION SECURITY_MODE=PASSKEY_FIXED_PIN BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Master_PassKey_Fixed (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Master_PassKey_Fixed +hex
  AfterMake: fromelf.exe --bin Master_PassKey_Fixed\Objects\BLE_Security_Master_PassKey_Fixed.axf --output Master_PassKey_Fixed\Objects\BLE_Security_Master_PassKey_Fixed.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Slave_JustWorks (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Slave_JustWorks +hex
  AfterMake: fromelf.exe --bin Slave_JustWorks\Objects\BLE_Security_Slave_JustWorks.axf --output Slave_JustWorks\Objects\BLE_Security_Slave_JustWorks.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION SECURITY_MODE=JUST_WORKS BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Master_JustWorks (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Master_JustWorks +hex
  AfterMake: fromelf.exe --bin Master_JustWorks\Objects\BLE_Security_Master_JustWorks.axf --output Master_JustWorks\Objects\BLE_Security_Master_JustWorks.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Slave_NumericComp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Slave_NumericComp +hex
  AfterMake: fromelf.exe --bin Slave_NumericComp\Objects\BLE_Security_Slave_NumericComp.axf --output Slave_NumericComp\Objects\BLE_Security_Slave_NumericComp.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION SECURITY_MODE=NUMERIC_COMPARISON BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Master_NumericComp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Security_Master_NumericComp +hex
  AfterMake: fromelf.exe --bin Master_NumericComp\Objects\BLE_Security_Master_NumericComp.axf --output Master_NumericComp\Objects\BLE_Security_Master_NumericComp.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
