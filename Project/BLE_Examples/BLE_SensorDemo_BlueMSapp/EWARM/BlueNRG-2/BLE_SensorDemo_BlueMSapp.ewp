# IAR project BLE_SensorDemo_BlueMSapp.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_BlueMSapp.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_BlueMSapp.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_BlueMSapp.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LowerApp_OTA (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_OTA_LOWER_APPLICATION=1; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1; OTA_EXTENDED_PACKET_LEN=1; BLE_STACK_CONFIGURATION=BLE_OTA_BASIC_CONFIGURATION
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_BlueMSapp_LowerApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_BlueMSapp_LowerApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_BlueMSapp_LowerApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_LOWER_APPLICATION=1
configuration HigherApp_OTA (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_OTA_HIGHER_APPLICATION=1; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1; OTA_EXTENDED_PACKET_LEN=1; BLE_STACK_CONFIGURATION=BLE_OTA_BASIC_CONFIGURATION
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_BlueMSapp_HigherApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_BlueMSapp_HigherApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_BlueMSapp_HigherApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_HIGHER_APPLICATION=1
configuration Use_OTA_ServiceManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_BlueMSapp_Use_OTA_ServiceManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_BlueMSapp_Use_OTA_ServiceManager.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_BlueMSapp_Use_OTA_ServiceManager.out
  ILINK.IlinkConfigDefines: ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group OTA
    ../../../../../Library/BLE_Application/OTA/src/: OTA_btl.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: BlueNRG1_it.c gatt_db.c sensor.c SensorDemo_BlueMS_main.c
