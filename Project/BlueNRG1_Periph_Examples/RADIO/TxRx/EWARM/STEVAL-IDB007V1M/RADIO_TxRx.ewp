# IAR project RADIO_TxRx.ewp, settings and files
configuration TX (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; USE_FULL_ASSERT; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_TxRx_TX.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_TX.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_TX.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RX (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: RADIO_TxRx_RX.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_RX.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_RX.out
configuration TX_Use_OTA_ResetManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; ST_USE_OTA_RESET_MANAGER; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: RADIO_TxRx_TX_Use_OTA_ResetManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_TX_Use_OTA_ResetManager.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_TX_Use_OTA_ResetManager.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=0x2800
configuration RX_Use_OTA_ResetManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: RADIO_TxRx_RX_Use_OTA_ResetManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_RX_Use_OTA_ResetManager.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_RX_Use_OTA_ResetManager.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=0x2800
  group Hal
    ../../../../../../Library/hal/src/: context_switch.s fifo.c hal_radio.c miscutil.c osal.c vtimer.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_timer.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Users
    ../../: BlueNRG1_it.c RADIO_RX_main.c RADIO_TX_main.c
    ../../../../../../Library/hal/src/: radio_ota.c
