# IAR project RADIO_StarNetwork.ewp, settings and files
configuration Master (ARM)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; PACKET_ENCRYPTION; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_StarNetwork_Master.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_StarNetwork_Master.bin"
  ILINK.IlinkOutputFile: RADIO_StarNetwork_Master.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Slave (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: RADIO_StarNetwork_Slave.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_StarNetwork_Slave.bin"
  ILINK.IlinkOutputFile: RADIO_StarNetwork_Slave.out
  group Hal
    ../../../../../../Library/hal/src/: vtimer.c context_switch.s hal_radio.c miscutil.c osal.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_timer.c BlueNRG1_gpio.c BlueNRG1_radio.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c misc.c
  group Platform_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group Users
    ../../: BlueNRG1_it.c RADIO_Master_main.c RADIO_Slave_main.c
