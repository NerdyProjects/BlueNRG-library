# Keil uVision project RADIO_AutomaticChMgm.uvprojx, settings and files
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_AutomaticChMgm +hex
  AfterMake: fromelf.exe --bin Release\Objects\RADIO_AutomaticChMgm.axf --output Release\Objects\RADIO_AutomaticChMgm.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: ..\..\;..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Library\hal\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group Hal
    ../../../../../../Library/hal/src/: vtimer.c context_switch.s hal_radio.c miscutil.c osal.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_timer.c BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Users
    ../../: BlueNRG1_it.c RADIO_AutomaticChMgm_main.c
