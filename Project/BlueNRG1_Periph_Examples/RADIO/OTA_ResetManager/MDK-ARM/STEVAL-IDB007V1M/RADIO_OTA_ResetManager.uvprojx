# Keil uVision project RADIO_OTA_ResetManager.uvprojx, settings and files
target Client (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_OTA_ResetManager_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\RADIO_OTA_ResetManager_Client.axf --output Client\Objects\RADIO_OTA_ResetManager_Client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ CONFIG_HW_HS_16MHZ CONFIG_DEVICE_BLUENRG_1 ST_OTA_SERVICE_MANAGER_APPLICATION=1 ST_OTA_MANAGER_APPLICATION=1 DEBUG_ BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: ..\..\;..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Library\hal\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x2800 "
  group Hal
    ../../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c hal_radio.c miscutil.c osal.c vtimer.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_radio.c BlueNRG1_sysCtrl.c BlueNRG1_timer.c BlueNRG1_uart.c misc.c
  group Platform_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group Users
    ../../: binary_image_txrx_example.c BlueNRG1_it.c bluenrg1_it_stub.c RADIO_OTAClient_main.c RADIO_OTAServer_main.c RADIO_OTAServerFixedImage_main.c ymodem.c
target Server_Ymodem (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: RADIO_OTA_ResetManager_Server_Ymodem +hex
  AfterMake: fromelf.exe --bin Server_Ymodem\Objects\RADIO_OTA_ResetManager_Server_Ymodem.axf --output Server_Ymodem\Objects\RADIO_OTA_ResetManager_Server_Ymodem.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SERVER_YMODEM CONFIG_HW_HS_16MHZ CONFIG_DEVICE_BLUENRG_1 ST_OTA_SERVICE_MANAGER_APPLICATION=1 DEBUG_ BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
target Server_FixedImage (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: RADIO_OTA_ResetManager_Server_FixedImage +hex
  AfterMake: fromelf.exe --bin Server_FixedImage\Objects\RADIO_OTA_ResetManager_Server_FixedImage.axf --output Server_FixedImage\Objects\RADIO_OTA_ResetManager_Server_FixedImage.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ CONFIG_HW_HS_16MHZ CONFIG_DEVICE_BLUENRG_1 ST_OTA_SERVICE_MANAGER_APPLICATION=1 _DEBUG BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
